Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-2200SA.IFC
Time: 2022-01-05T02:08:37
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 2200底座
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 22SA外殼
In: Default Storey
PredefinedType: ELEMENT; Material: PW80:Mi:0:244:Ar:0:-1:C1:1:2:3:Re:27:Di:35:

# IfcBuildingElementProxy: 22外殼螺絲 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: SUS出風口B
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 出風口柵門3
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
